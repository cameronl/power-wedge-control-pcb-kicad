# Repository cameronl/power-wedge-control-pcb-kicad

## KiCad design power-wedge-control.kicad_pcb

Parts:
A1: Arduino_UNO_R3
A2: Adafruit_Feather_HUZZAH32_ESP32; Adafruit_Feather
C1, C2: 470n; C_0603_1608Metric
C3, C4: NOSTUFF; C_0603_1608Metric
C5, C7, C14: 10u; C_1206_3216Metric
C6, C8, C13, C15, C16: 100n; C_0603_1608Metric
D1, D2: LL4148; D_MiniMELF
J1: Conn_01x02; TerminalBlock_Phoenix_PT-1,5-2-3.5-H_1x02_P3.50mm_Horizontal
J2, J4, J5: Conn_01x03; TerminalBlock_Phoenix_PT-1,5-3-3.5-H_1x03_P3.50mm_Horizontal
J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J6: Conn_01x06_Female; TerminalBlock_Phoenix_PT-1,5-6-3.5-H_1x06_P3.50mm_Horizontal
J7: Conn_01x04_Female; TerminalBlock_Phoenix_PT-1,5-4-3.5-H_1x04_P3.50mm_Horizontal
J8: Conn_01x04; PinHeader_1x04_P2.54mm_Horizontal
J9: MicroSD_Hirose_DM3D-SF; microSD_HC_Hirose_DM3D-SF
J10: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
J11: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J12: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Horizontal
JP2, JP3: Jumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
L1, L2, L3: 600R/200mA; L_0603_1608Metric
LED1, LED2: LED; LED_0603_1608Metric
LED3, LED4: LED_GRN; LED_0603_1608Metric
Q1, Q3, Q5, Q6: MMBT3904L; SOT-23
Q2, Q4: DMP3099L; SOT-23
R1, R4, R11, R12: 10k; R_0603_1608Metric
R2, R5, R9, R10, R13, R14, R21, R22: 1k; R_0603_1608Metric
R3, R6: 100k; R_0603_1608Metric
R7, R8, R23: 200k; R_0603_1608Metric
R24: 4k7; R_0603_1608Metric
R25: 470; R_0603_1608Metric
R26, R27: 47k; R_0603_1608Metric
SW1: SW_SPST; PinHeader_1x02_P2.54mm_Horizontal
TP1, TP2, TP3, TP4: TestPoint; TestPoint_THTPad_D1.5mm_Drill0.7mm
U1: LM1117-5.0; TO-252-2
U3: TLV70233DBV; SOT-23-5
U4, U7: LTV-817S; SMDIP-4_W9.53mm
U5, U6: NC7WZ17P6X; SOT-363_SC-70-6
U8: SN74LVC08ADRG3; SOIC-14_3.9x8.7mm_P1.27mm
U9: NC7WZ14P6X; SOT-363_SC-70-6
U10, U11: SN74LVC1G32DBVR; SOT-23-5

Connections:
+3V3: C14.1, C15.1, C16.1, J9.4 (VDD), JP1.1 (A), JP2.1 (A), SW1.2 (B), TP3.1, U3.5 (OUT), U5.5 (VCC), U6.5 (VCC), U8.14 (VCC), U9.5 (VCC), U10.5 (VCC), U11.5 (VCC)
+5V: C7.1, C8.1, JP3.1 (A), L3.1, TP2.1, U1.2 (VO), U3.1 (IN), U3.3 (EN)
+12V: A1.8 (VIN), C5.1, C6.1, J1.1, Q2.2 (S), Q4.2 (S), R3.1, R6.1, R25.1, TP1.1, U1.3 (VI)
/ANGL1: J4.2, L1.1
/ANGL1_REF5V: A1.11 (A2), C1.1, C3.1, J8.1, J12.4, L1.2, R7.2
/ANGL2: J5.2, L2.1
/ANGL2_REF5V: A1.12 (A3), C2.1, C4.1, J8.3, J12.3, L2.2, R8.2
/AREF: A1.30 (AREF), J10.3
/BTN_DN: A1.19 (D4), J11.5, U8.9 (3A); also elsewhere on the board
/BTN_PWR: JP3.2 (B); also elsewhere on the board
/BTN_UP: A1.20 (D5), J11.6, U8.12 (4A); also elsewhere on the board
/CS: A1.25 (D10), J10.8, U5.1 (A1)
/EN_MANUAL: R23.2, R24.2, SW1.1 (A), TP4.1, U8.10 (3B), U8.13 (4B), U9.1 (A1), U9.3 (A2)
/EN_OUTPUT: JP1.2 (B), R11.2, R12.2
/EN_RELAY_DN: J3.1, R4.2, R14.2, U10.4
/EN_RELAY_UP: J3.2, R1.2, R13.2, U11.4
/G: A1.22 (D7), J6.4, J11.8
/MCU_RELAY_DN: A1.17 (D2), J11.3, R27.2, U8.2 (1B)
/MCU_RELAY_UP: A1.18 (D3), J11.4, R26.2, U8.5 (2B)
/MISO: A1.27 (D12), J10.6, U6.4 (Y2)
/MOSI: A1.26 (D11), J10.7, U5.3 (A2)
/RCK: A1.23 (D8), J6.3, J10.10
/RELAY_DN+: D2.1 (K), J2.1, Q4.3 (D), R10.2
/RELAY_UP+: D1.1 (K), J2.3, Q2.3 (D), R9.2
/SCK: A1.28 (D13), J10.5, U6.1 (A1)
/SD_CLK: J9.5 (CLK), U6.6 (Y1)
/SD_CS: J9.2 (DAT3/CD), U5.6 (Y1)
/SD_DI: J9.3 (CMD), U5.4 (Y2)
/SD_DO: J9.7 (DAT0), U6.3 (A2)
/SENS_PWR: C13.1, J4.3, J5.3, J8.2, L3.2
/SER_IN: A1.21 (D6), J6.5, J11.7
/SRCK: A1.24 (D9), J6.2, J10.9
/SW1EXT: J7.2, R21.2
/SW2EXT: J7.3, R22.2
/UI_PWR: J6.6, JP2.2 (B)
/~SW1: U4.4; also elsewhere on the board
/~SW2: U7.4; also elsewhere on the board
GND: A1.6 (GND), A1.7 (GND), A1.29 (GND), A2.4 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C13.2, C14.2, C15.2, C16.2, D1.2 (A), D2.2 (A), J1.2, J2.2, J4.1, J5.1, J6.1, J7.1, J8.4, J9.6 (VSS), J9.11 (SHIELD), J10.4, LED1.1 (K), LED2.1 (K), LED3.1 (K), LED4.1 (K), Q1.2 (E), Q3.2 (E), R7.1, R8.1, R23.1, R26.1, R27.1, U1.1 (GND), U3.2 (GND), U3.4 (NC), U4.2, U4.3, U5.2 (GND), U6.2 (GND), U7.2, U7.3, U8.7 (GND), U9.2 (GND), U10.3 (GND), U11.3 (GND); also elsewhere on the board
unnamed: A1.9 (A0), J12.6
unnamed: A1.10 (A1), J12.5, R24.1
unnamed: A1.13 (SDA/A4), J12.2
unnamed: A1.14 (SCL/A5), J12.1
unnamed: A1.15 (D0/RX), J11.1
unnamed: A1.16 (D1/TX), J11.2
unnamed: A1.31 (SDA/A4), J10.2
unnamed: A1.32 (SCL/A5), J10.1
unnamed: J7.4, R25.2
unnamed: LED1.2 (A), R9.1
unnamed: LED2.2 (A), R10.1
unnamed: LED3.2 (A), R13.1
unnamed: LED4.2 (A), R14.1
unnamed: Q1.1 (B), R1.1
unnamed: Q1.3 (C), Q6.2 (E)
unnamed: Q2.1 (G), R2.1, R3.2
unnamed: Q3.1 (B), R4.1
unnamed: Q3.3 (C), Q5.2 (E)
unnamed: Q4.1 (G), R5.1, R6.2
unnamed: Q5.1 (B), R11.1
unnamed: Q5.3 (C), R5.2
unnamed: Q6.1 (B), R12.1
unnamed: Q6.3 (C), R2.2
unnamed: R21.1, U4.1
unnamed: R22.1, U7.1
unnamed: U8.1 (1A), U9.6 (Y1)
unnamed: U8.4 (2A), U9.4 (Y2)
unnamed: U8.8 (3Y), U10.1
unnamed: U8.3 (1Y), U10.2
unnamed: U8.11 (4Y), U11.1
unnamed: U8.6 (2Y), U11.2

Notes on the sheet:
TODO: More capacitance and/or UVLP? To protect/indicate battery input undervolt.
TODO: Invert output_enable to output_disable?
TODO: Load switch controlling sensor power (for turn on slew rate or sleep)?
TODO: 3V for UI_PWR
TODO: EN manual to MCU input pin.
TODO: Which voltage regulator should UI_PWR, BTN_PWR, EN_OUT come from?
Inverted, open-collector output
TODO: 4 wires to up/down buttons: +12V, GND, UP input, DN input.
TODO: Reverse polarity, short-circuit, power good?
TODO: Add UP/DN dash buttons (w/hardware debounce)
TODO: Indicator LEDs for relays.
To Angle Sensor 1
TODO: Analog front end?
TODO: Weak pull-up on A0. So we can use without keypad shield.
TODO: MicroSD card?
TODO: EN manual test/engr pin.
Display design: 7-segment w/ dot for moving? 2 displays: 1 for set point, 1 for actual? 3 small digits for angle, 1 large for set point? Use hex so angle fits in one digit. LCD? OLED?
TODO: HW switch pin to disable control inside MCU?
TODO: Test points on angle sensors at MCU pins?
Test points for angle sensors
TODO: FET Vgs max is 20V, Add zener to allow higher headroom on 12V?
5V Regulated Power Supply
Relay Control
Hardware Manual Control Option
Power Input
Up/Down Buttons
3.3V Regulated Power Supply
TODO: Button (hardware) debounce timing/tuning.
TODO: Analog ref?
TODO: Manual control option? External relay enable? Or just from MCU?
TODO: HW switch to disconnect relays from MCU?
TODO: Optocouplers on relay enable pins to isolate MCU from 12V?
TODO: Board id & revision on back/front.
Support Active-High (15V Max) Switch Input
To Angle Sensor 2
Test point and LED indicators
TODO: When to sleep/power down? A: 1.) Stay ON anytime that the wedge is DOWN. 2.) Turn ON for 30 secs after a button press (if wedge is not down).
TODO: 5V buck power supply from 12V
TODO: Test points, pins, or jumpers for accessing key circuits?
TODO: Do we need 3V3? Or does Huzzah32 Feather make 3.3V?

Parts:
C9, C10, C11, C12: 1uF; C_0603_1608Metric
D3, D4: LL4148; D_MiniMELF
R15, R17: 6.8k; R_0603_1608Metric
R16, R18: 8.2k; R_0603_1608Metric
R19, R20: 4k7; R_0603_1608Metric
U2: NC7WZ14P6X; SOT-363_SC-70-6

Connections:
/BTN_DN: R20.1; also elsewhere on the board
/BTN_PWR: R15.2, R17.2, U2.5 (VCC); also elsewhere on the board
/BTN_UP: R19.1; also elsewhere on the board
/~SW1: D3.2 (A), R15.1, R16.2; also elsewhere on the board
/~SW2: D4.2 (A), R17.1, R18.2; also elsewhere on the board
GND: C9.2, C10.2, C11.2, C12.2, U2.2 (GND); also elsewhere on the board
unnamed: C9.1, C10.1, D3.1 (K), R16.1, U2.1 (A1)
unnamed: C11.1, C12.1, D4.1 (K), R18.1, U2.3 (A2)
unnamed: R19.2, U2.6 (Y1)
unnamed: R20.2, U2.4 (Y2)

Notes on the sheet:
Expecting GND or open on switch inputs.
External Switch Contacts
Debounced Switch State Output
TODO: Notes re: timing and VDD expectations.
Two Switches With Hardware Debounce

Board: 2 copper layers, 77.2 x 64.5 mm, 92 parts (13 on the bottom side), 73 nets.

## Commit log

2021-11-25 Initial project with relay control by P-CH FETs.
2021-12-29 KiCad 6. Add 7805 reg, Arduino Uno, ESP32 footprints, angle sensor input
    Add todo notes.
    WIP.
2022-01-02 WIP. Add relay LEDs, ui/display connection.
2022-01-02 Add output enable, MCU wants relay up/down green LEDs.
2022-01-03 Line up inverter, output enable transistors.
2022-01-08 Swap CLK and LE pins on LED UI display connection.
2022-01-09 Add Up/Down buttons switch input with hardware debounce.
    HW debounce copied from ultrasonic PCB project.
2022-01-09 Fix hardware debounce circuit (was incorrect).
2022-01-09 Flip Arduino UNO R3 footprint.
2022-01-09 WIP. Line up all connectors along bottom edge.
    Rotate board.
    Focus on Uno R3 for now.
2022-01-10 More compact.
2022-01-11 Add design rules, net classes.
2022-01-11 Connect LED UI display connector to MCU pins.
2022-01-11 Route majority of sensor, button, LED UI traces.
2022-01-12 Route remaining traces (relay control, 5V).
    Silkscreen clean up.
2022-01-12 100n on sensor power. Connector silkscreen labels larger (1.5mm)
2022-01-12 Label connector pins on back silkscreen.
2022-01-12 Label 5V reg pins, output enable.
2022-01-15 Add test points for angle sensors. Add todo notes.
2022-01-16 WIP. Add SD card, 3.3V reg. Move MCU pins for relays, up/down buttons.
    Using 4050 hex buffer to level shift 5V MCU to 3.3V SD card.
2022-01-16 Switch to NC7WZ17P6X buffers for level shifting to SD card.
2022-01-17 Change 5V regulator LM7805 to LM1117.
2022-01-18 Flip J3 relay test points away from Uno USB connector.
2022-01-19 Change 7SegDisp UI connection pin labels for TLC6C5912.
2022-01-21 Move power supply near angle sensors. Swap several MCU pins.
    Move button debounce up near MCU pins.
    Add top layer zones for thermal at voltage regs.
2022-01-21 Add ferrite bead on sensor power.
2022-01-21 Add GND to angle sensor test points.
2022-01-28 WIP. Add support for active-high (15V max) switch input to schematic.
2022-01-29 Add support for active-high (15V max) switch input to PCB layout.
2022-02-01 Switch to optocouplers, remove GND-Open option for up/down switch input.
2022-02-01 Exclude Adafruit Huzzah32 ESP32 from board/bom.
2022-02-02 Add extra test points for mcu pins, power supply rails.
    Reduce back ground plane clearance.
2022-02-02 Add 100n on 3V3 at sdcard. More clearance near R21. Fix top zone clearances.
2022-02-02 Clean up GND via stapling grid on power supply zones.
2022-02-02 Add front GND zone around angle sensor input.
2022-02-04 Add hardware manual control option to schematic and WIP layout.
    TODO: 4-wires to up/down buttons: +12V, GND, UP input, DN input.
    TODO: EN manual to MCU input pin.
    TODO: EN manual test/engr pin.
2022-02-04 Hardware manual control option layout 2.
2022-02-04 Finish layout for hardware manual control option.
2022-02-04 Add test point on manual enable and connect to MCU A1 pin.
2022-02-04 4 wires to up/down buttons: +12V, GND, UP input, DN input.
    Move terminal block pin silkscreen labels away from edge.
2022-02-04 Add board id & revision, reverse-polarity/unprotected warning on back.
2022-02-04 Add board name, revision to front silkscreen and title block.
    Extend 5V front filled zone.
2022-02-05 Add 470 Ω resistor to limit current on +12V pin to up/down buttons.
2022-02-06 Remove unprotected warning on back.
2022-02-06 Set Solder Mask Clearance to 0.0508mm
2022-02-06 Add gerber files for JLCPCB.
    Add order number location on back silkscreen.
2022-02-25 Add Bill Of Materials (BOM) for rev1.
2022-02-25 Fix (swap) R17, R18 silkscreen references.
2022-02-25 Update value for SN74LVC1G32 to specific part.
2022-03-01 Add pull-down resistors on relay up+down pins from MCU.
2022-03-29 Add todo notes.
2023-03-07 KiCad 7
